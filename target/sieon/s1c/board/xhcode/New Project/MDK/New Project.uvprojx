# Keil uVision project New Project.uvprojx, settings and files
target New Project_Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32F4A0SIHB HDSC
  pack: HDSC.HC32F4A0.1.0.8.pack
  cpu: IROM1(0x0,0x200000) IROM2(0x3000000,0x1800) IRAM1(0x1FFE0000,0x80000) IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ESEL ELITTLE
  output: New Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __DEBUG,HC32F4A0,USE_DDL_DRIVER,
  c include: .\common;.\source;.\driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x3000000 size 0x1800
  memory RVCT9: RAM 0x1FFE0000 size 0x80000
  memory RVCT10: RAM 0x200F0000 size 0x1000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32f4a0.s
    ./common/: system_hc32f4a0.c
  group source
    ./source/: main.c
  group driver
    ./driver/src/: hc32_ll.c hc32_ll_icg.c hc32_ll_utility.c hc32_ll_pwc.c hc32_ll_sram.c hc32_ll_efm.c hc32_ll_clk.c hc32_ll_gpio.c hc32_ll_fcg.c hc32_ll_aos.c hc32_ll_cmp.c hc32_ll_interrupts.c hc32f4a0_ll_interrupts_share.c hc32_ll_usart.c
target New Project_Release (5060020::V5.06 (build 20)::ARMCC)
  device: HC32F4A0SIHB HDSC
  pack: HDSC.HC32F4A0.1.0.8.pack
  cpu: as above
  output: New Project +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: HC32F4A0,USE_DDL_DRIVER,
  c include: .\common;.\source;.\driver\inc;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x3000000 size 0x1800
  memory RVCT9: RAM 0x1FFE0000 size 0x80000
  memory RVCT10: RAM 0x200F0000 size 0x1000
  link misc: --keep=*Handler
