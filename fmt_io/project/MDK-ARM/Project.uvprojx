# Keil uVision project Project.uvprojx, settings and files
target StarryIO (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F100C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: starryio
  AfterMake: fromelf --bin !L --output starryio.bin
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD_VL
  c misc: --c99 --gnu
  c include: ..\;..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8001000 size 0xf000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ../: stm32f10x_it.c main.c usart.c time.c protocol.c led.c lidar_lite.c sbus.c pwm.c debug.c global.c fmu_manager.c ppm_decoder.c
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../: system_stm32f10x.c
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group MDK-ARM
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md_vl.s
  group Doc
    ./: readme.txt
software components: CMSIS:CORE 5.0.1
